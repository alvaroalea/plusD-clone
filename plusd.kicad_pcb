# Repository alvaroalea/plusD-clone

File README.md:

# The +D Interface Disk for ZX Spectrum

UNDER LICENSE Creative Commons Attribution-NonCommercial-ShareAlike 4.0 International (CC BY-NC-SA 4.0)
- If you remix, transform, or build upon the material, you must distribute your contributions under the same license as the original.
- You may not use the material for commercial purposes.
- You must give appropriate credit, provide a link to the license, and indicate if changes were made. You may do so in any reasonable manner, but not in any way that suggests the licensor endorses you or your use.

the schematic and PCB for this interfaz, make in KICAD
Including gerber files to direct order, the PCB is less than 10x10cm so it's very cheap.
Al BOM for order 10 units is also available, some PCB manufacturer allow to order at same time than PCB
Aditionaly ICs and Edge conector is needed.

IC for floppy controler is a dificult to found WD1772, in theory WD1770 can be used as a alternative.
Also WD1773, probably can be used, JP4 and JP5 must be changed to allow alternative motor control.
The interface has been only tested with WD1772 and VL1772-2PH

The Advantege of this interfaz over the original are:

- 4 Banks of ROM, so you can swap between G+Dos and Unidos, selectable by dip-switches

- Included Fixed for +2A/+3, so can be used in any ZX Spectrum, selection by jumpers

- Kempston Joystick Interface included, can be disable by dip-switch

- Reset Button

- Posibility of use crossed and plain floppy cable, and invert Drive 1 and Drive 2, very usefull if you have a Gotek and a real floppy.

## KiCad design plusd.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C16: 100n; C_Disc_D5.0mm_W2.5mm_P5.00mm
C13: 33p; C_Disc_D5.0mm_W2.5mm_P5.00mm
C14, C17, C18: 100u/16 V; CP_Radial_D7.5mm_P2.50mm
C15: 100p; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1, D5: LED; LED_D5.0mm
D2, D3, D4: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
IC1: WD1772; DIP-28_W15.24mm_LongPads
IC2: AT28C256; DIP-28_W15.24mm_LongPads
IC3: 6264; DIP-28_W15.24mm_LongPads
IC4: PAL20L8; DIP-24_W7.62mm_LongPads
IC5: 74LS06; DIP-14_W7.62mm_LongPads
IC6: 74LS126; DIP-14_W7.62mm_LongPads
IC7: 74LS374; DIP-20_W7.62mm_LongPads
IC8: 74LS175; DIP-16_W7.62mm_LongPads
IC9: 74LS00; DIP-14_W7.62mm_LongPads
IC10: 74LS27; DIP-14_W7.62mm_LongPads
IC11: GAL22V10; DIP-24_W7.62mm_LongPads
IC12: L7805; TO-220-3_Vertical
J1: ZX_Spectrum_Connector_GENERIC_SORTED; ZX_CONN
J2: Conn_02x17_Odd_Even; PinHeader_2x17_P2.54mm_Vertical
J3: Conn_02x13_Odd_Even; PinHeader_2x13_P2.54mm_Vertical
J4: DB9_Male; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_Hou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
J5: DB25_Female_MountingHoles; DSUB-25_Female_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_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
JP1, JP2: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
JP4: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
JP5: Conn_02x02_Odd_Even; PinHeader_2x02_P2.54mm_Vertical
JP6, JP7: Jumper_NC_Dual; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
MK1: Mounting_Hole_PAD; MountingHole_3mm_Pad_Via
MK2, MK3: Mounting_Hole; MountingHole_3mm
R1, R2, R3, R4: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5, R7, R8: 2K2; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6, R10: 680; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9: 270; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R11, R12: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1, SW2: SW_DPST_x2; SW_TH_Tactile_Omron_B3F-10xx
SW3: SW_DIP_x03; SW_DIP_SPSTx03_Slide_6.7x9.18mm_W7.62mm_P2.54mm_LowProfile
Y1: 8.000Mhz; Crystal_HC18-U_Vertical

Connections:
+5V: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C18.1, IC1.15 (VCC), IC2.27 (~WR), IC2.28 (VCC), IC3.26 (CE2), IC3.28 (VCC), IC4.24 (VCC), IC5.14 (VCC), IC6.1, IC6.10, IC6.13, IC6.14 (VCC), IC7.20 (VCC), IC8.16 (VCC), IC9.14 (VCC), IC10.14 (VCC), IC11.24 (VCC), J4.7, JP1.2, JP6.3, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R10.2, R11.2, R12.2
+9V: C1.2, C17.1, IC12.1 (IN), J1.A4 (9V_N/C)
/A0: IC2.10 (A0), IC3.10 (A0), IC10.9, J1.A9 (A0)
/A1: IC2.9 (A1), IC3.9 (A1), IC4.13 (I13), J1.A10 (A1)
/A2: IC2.8 (A2), IC3.8 (A2), IC4.14 (I14), J1.A11 (A2)
/A3: IC1.3 (A0), IC2.7 (A3), IC3.7 (A3), IC4.11 (I11), IC11.4 (I4/PD), J1.A12 (A3)
/A4: IC1.4 (A1), IC2.6 (A4), IC3.6 (A4), IC4.10 (I10), IC11.3 (I3), J1.A24 (A4)
/A5: IC2.5 (A5), IC3.5 (A5), IC4.9 (I9), J1.A23 (A5), SW3.4
/A6: IC2.4 (A6), IC3.4 (A6), IC4.8 (I8), J1.A22 (A6)
/A7: IC2.3 (A7), IC3.3 (A7), IC10.10, J1.A21 (A7)
/A8: IC2.25 (A8), IC3.25 (A8), IC10.11, J1.B26 (A8)
/A9: IC2.24 (A9), IC3.24 (A9), IC10.13, J1.A27 (A9)
/A10: IC2.21 (A10), IC3.21 (A10), IC10.1, J1.B27 (A10)
/A11: IC2.23 (A11), IC3.23 (A11), IC10.2, J1.A28 (A11)
/A12: IC2.2 (A12), IC3.2 (A12), IC10.3, J1.A2 (A12)
/A13: IC4.3 (I3), J1.B2 (A13)
/A14: IC4.1 (I1), J1.A1 (A14)
/A15: IC4.2 (I2), J1.B1 (A15)
/D0: IC1.5 (DI0), IC2.11 (D0), IC3.11 (D0), IC7.18 (D7), IC8.4 (D0), IC11.23 (IO1), J1.B6 (D0)
/D1: IC1.6 (DI1), IC2.12 (D1), IC3.12 (D1), IC7.3 (D0), IC8.5 (D1), IC11.22 (IO2), J1.B7 (D1)
/D2: IC1.7 (DI2), IC2.13 (D2), IC3.13 (D2), IC7.4 (D1), IC11.21 (IO3), J1.B8 (D2)
/D3: IC1.8 (DI3), IC2.15 (D3), IC3.15 (D3), IC7.17 (D6), IC11.20 (I04), J1.B11 (D3)
/D4: IC1.9 (DI4), IC2.16 (D4), IC3.16 (D4), IC7.14 (D5), IC11.19 (IO5), J1.B12 (D4)
/D5: IC1.10 (DI5), IC2.17 (D5), IC3.17 (D5), IC7.7 (D2), IC11.18 (IO6), J1.B10 (D5)
/D6: IC1.11 (DI6), IC2.18 (D6), IC3.18 (D6), IC7.8 (D3), IC8.12 (D2), IC11.17 (IO7), J1.B9 (D6)
/D7: IC1.12 (DI7), IC2.19 (D7), IC3.19 (D7), IC6.6, IC7.13 (D4), IC8.13 (D3), IC11.16 (IO8), J1.B3 (D7)
/DIR: IC5.10, J2.18
/DS0: JP4.3, JP5.4
/DS1: J2.12, JP5.1
/HEAD: IC6.3, J2.32
/INDEX: IC1.24 (~IP), J2.8, R1.1
/IOREQ: IC4.5 (I5), IC11.5 (I5), J1.B17 (IOREQ)
/M1: IC10.4, J1.B24 (M1)
/MOTOR_ON: J2.16, JP4.1, JP7.2
/MREQ: IC4.4 (I4), J1.B16 (MREQ)
/RD: IC2.22 (~OE), IC3.22 (~OE), IC4.6 (I6), IC11.6 (I6), J1.B18 (RD)
/RESET: C16.2, IC1.13 (~MR), IC8.1 (~Mr), J1.A20 (~RESET), SW2.3 (A)
/STEP: IC5.6, J2.20
/TRACK_0: IC1.23 (~TR00), J2.26, R2.1
/WR: IC1.2 (R/~W), IC3.27 (~WR), IC4.7 (I7), IC11.2 (I2), J1.B19 (WR)
ALT_MOTOR_ON: IC11.14 (IO10), JP7.3
DSK_CS: IC4.19 (IO19), IC8.9 (Cp)
FDC_CS: IC1.1 (~CS), IC4.22 (IO22), IC11.7 (I7)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C15.1, C16.1, C17.2, C18.2, D5.1 (K), IC1.14 (GND), IC1.26 (~DDEN), IC2.14 (GND), IC3.1 (N/C), IC3.14 (GND), IC4.12 (GND), IC5.7 (GND), IC6.7 (GND), IC7.1 (OE), IC7.10 (GND), IC8.8 (GND), IC9.7 (GND), IC10.7 (GND), IC11.12 (GND), IC12.2 (GND), J1.A6 (GND), J1.A7 (GND), J1.A14 (GND), J2.1, J2.3, J2.5, J2.7, J2.9, J2.11, J2.13, J2.15, J2.17, J2.19, J2.21, J2.23, J2.25, J2.27, J2.29, J2.31, J2.33, J3.10, J3.12, J3.14, J3.16, J3.18, J3.20, J3.22, J3.24, J4.8, J5.0 (PAD), J5.18, J5.19, J5.20, J5.21, J5.22, J5.23, J5.24, J5.25, MK1.1, SW2.4 (B), SW3.1, SW3.2
J1-Up: IC11.10 (I10), J4.1
J2-Down: IC11.11 (I11), J4.2
J3-Left: IC11.8 (I8), J4.3
J4-Right: IC11.9 (I9), J4.4
J6-Fire: IC11.13 (I12), J4.6
JOY_EN: IC11.1 (I1/CLK), SW3.3
NMI: J1.B14 (~NMI), SW1.1 (A)
unnamed: C13.1, Y1.1
unnamed: C13.2, IC1.18 (CLK), IC9.3, R7.2
unnamed: C14.1, IC9.6, R8.2
unnamed: C14.2, IC9.1, IC9.2, R7.1
unnamed: C15.2, IC4.23 (I23), R9.1
unnamed: D1.1 (K), IC4.21 (IO21), JP2.2, SW1.2 (B)
unnamed: D1.2 (A), R6.1
unnamed: D2.2 (A), JP2.1
unnamed: D3.2 (A), D4.2 (A), JP2.3
unnamed: D5.2 (A), R10.1
unnamed: IC1.16 (STEP), IC5.5
unnamed: IC1.17 (DIRC), IC5.11
unnamed: IC1.19 (~RD), J2.30, R4.1
unnamed: IC1.20 (MOTOR), JP6.1
unnamed: IC1.21 (WG), IC5.13
unnamed: IC1.22 (WD), IC5.1
unnamed: IC1.25 (~WPRT), J2.28, R3.1
unnamed: IC5.2, J2.22
unnamed: IC5.3, JP6.2
unnamed: IC5.4, JP7.1
unnamed: IC5.8, J3.1, J5.1
unnamed: IC5.9, IC8.10 (Q2)
unnamed: IC5.12, J2.24
unnamed: IC6.2, IC8.14 (~Q3)
unnamed: IC6.4, IC9.8
unnamed: IC6.5, J3.21, J5.11, R5.1
unnamed: IC6.8, JP5.2
unnamed: IC6.9, IC8.6 (~Q1)
unnamed: IC6.11, JP5.3
unnamed: IC6.12, IC8.3 (~Q0)
unnamed: IC7.2 (O0), J3.5, J5.3
unnamed: IC7.5 (O1), J3.7, J5.4
unnamed: IC7.6 (O2), J3.13, J5.7
unnamed: IC7.9 (O3), J3.15, J5.8
unnamed: IC7.12 (O4), J3.17, J5.9
unnamed: IC7.15 (O5), J3.11, J5.6
unnamed: IC7.16 (O6), J3.9, J5.5
unnamed: IC7.19 (O7), J3.3, J5.2
unnamed: IC9.4, IC9.5, R8.1, Y1.2
unnamed: IC9.11, IC10.5
unnamed: IC10.6, R9.2
unnamed: IC9.13, IC10.8
unnamed: IC9.12, IC10.12
unnamed: IC12.3 (OUT), JP1.1
unnamed: J2.10, JP4.2
unnamed: J2.14, JP4.4
PRN_CS: IC4.18 (IO18), IC7.11 (Cp)
PRN_STR: IC4.20 (I020), IC9.9, IC9.10
RAM_CS: IC3.20 (~CE1), IC4.16 (IO16)
ROM_A13: IC2.26 (A13), R12.1, SW3.5
ROM_A14: IC2.1 (A14), R11.1, SW3.6
ROM_CS: IC2.20 (~CE), IC4.15 (IO15)
ZX_ROMOE1: D4.1 (K), J1.B4 (N/C-ROM1_OE)
ZX_ROMOE2: D3.1 (K), J1.A15 (VIDEO-ROM2_OE)
ZX_ROMOE48: D2.1 (K), J1.A25 (ROMCS-N/C)
plus3_5V: J1.A3 (+5Vcc), JP1.3

Notes on the sheet:
WRITE PROT
DATA_READ
DATA_WRITE
GATE_WRITE
READY / Disc Chan.
DENSITY SEL
N/C
MOTOR 1
DS0
DS1
MOTOR 0
MOTOR
DS2
DS0
DS3
MODO XT: 2-3 (Cable plano, disqueteras DS0, DS1) MODO AT.: 1-2, 3-4 (Cable con cruze, ambas disqueteras DS1)
normal: 1 y 2, 3 y 4, - DS0 es DS0 y DS1 es DS1 invertido: 1 y 3, 2 y 4 - DS0 es DS1 DS1 es DS0

Board: 2 copper layers, 99.1 x 99.1 mm, 67 parts (2 on the bottom side), 107 nets.

Other parts of the board:
SLOT: MountingHole_1mm
SLOT#2, SLOT#3: MountingHole_1mm

## KiCad design Rev_02/plusd.kicad_pcb

Parts:
C1, C6, C7: 100u; CP_Radial_D7.5mm_P2.50mm
C2: 33p; C_Disc_D5.0mm_W2.5mm_P2.50mm
C3, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17: 100n; C_Disc_D5.0mm_W2.5mm_P2.50mm
C4: 100p; C_Disc_D5.0mm_W2.5mm_P2.50mm
C5: 10n; C_Disc_D5.0mm_W2.5mm_P2.50mm
D1, D3, D4: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D2: LED; LED_D5.0mm
J1: Conn_02x17_Odd_Even; PinHeader_2x17_P2.54mm_Vertical
J2: ZX_Spectrum_Connector_GENERIC_SORTED; ZX_CONN
J3: Conn_02x13_Odd_Even; PinHeader_2x13_P2.54mm_Vertical
J4: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J5: DB25_Female_MountingHoles
MK1: Mounting_Hole; MountingHole_3mm
MK2: Mounting_Hole_PAD; MountingHole_3mm_Pad_Via
R1, R2, R3, R4: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5, R6, R7, R9: 2K2; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8: 270; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10, R11: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: SW_DPST_x2; SW_TH_Tactile_Omron_B3F-10xx
SW2: SW_DIP_x02; SW_DIP_SPSTx02_Slide_9.78x7.26mm_W7.62mm_P2.54mm
U1: 74LS06; DIP-14_W7.62mm_LongPads
U2: AT28C256; DIP-28_W15.24mm_LongPads
U3: WD1772; DIP-28_W15.24mm_LongPads
U4: 74LS00; DIP-14_W7.62mm_LongPads
U5: 74LS126; DIP-14_W7.62mm_LongPads
U6: 74LS175; DIP-16_W7.62mm_LongPads
U7: 62256; DIP-28_W15.24mm_LongPads
U8: PAL20L8; DIP-24_W7.62mm_LongPads
U9: 74LS374; DIP-20_W7.62mm_LongPads
U10: 74LS27; DIP-14_W7.62mm_LongPads
U12: L7805; TO-220-3_Vertical
Y1: 8.000Mhz; Crystal_HC18-U_Vertical

Connections:
+5V: C7.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, J2.A3 (+5Vcc), R1.2, R2.2, R3.2, R4.2, R7.2, R9.2, R10.2, R11.2, U1.14 (VCC), U2.27 (~WR), U2.28 (VCC), U3.15 (VCC), U4.7 (GND), U5.1, U5.10, U5.13, U5.14 (VCC), U6.16 (VCC), U7.28 (VCC), U8.24 (VCC), U9.20 (VCC), U10.14 (VCC), U12.3 (OUT)
+9V: C5.2, C6.1, J2.A4 (9V_N/C), U12.1 (IN)
/A0: J2.A9 (A0), U2.10 (A0), U7.10 (A0), U10.9
/A1: J2.A10 (A1), U2.9 (A1), U7.9 (A1), U8.13 (I13)
/A2: J2.A11 (A2), U2.8 (A2), U7.8 (A2), U8.14 (I14)
/A3: J2.A12 (A3), U2.7 (A3), U3.3 (A0), U7.7 (A3), U8.11 (I11)
/A4: J2.A24 (A4), U2.6 (A4), U3.4 (A1), U7.6 (A4), U8.10 (I10)
/A5: J2.A23 (A5), U2.5 (A5), U7.5 (A5), U8.9 (I9)
/A6: J2.A22 (A6), U2.4 (A6), U7.4 (A6), U8.8 (I8)
/A7: J2.A21 (A7), U2.3 (A7), U7.3 (A7), U10.10
/A8: J2.B26 (A8), U2.25 (A8), U7.25 (A8), U10.11
/A9: J2.A27 (A9), U2.24 (A9), U7.24 (A9), U10.13
/A10: J2.B27 (A10), U2.21 (A10), U7.21 (A10), U10.1
/A11: J2.A28 (A11), U2.23 (A11), U7.23 (A11), U10.2
/A12: J2.A2 (A12), U2.2 (A12), U7.2 (A12), U10.3
/A13: J2.B2 (A13), U8.3 (I3)
/A14: J2.A1 (A14), U8.1 (I1)
/A15: J2.B1 (A15), U8.2 (I2)
/D0: J2.B6 (D0), U2.11 (D0), U3.5 (DI0), U6.4 (D0), U7.11 (D0), U9.18 (D7)
/D1: J2.B7 (D1), U2.12 (D1), U3.6 (DI1), U6.5 (D1), U7.12 (D1), U9.3 (D0)
/D2: J2.B8 (D2), U2.13 (D2), U3.7 (DI2), U7.13 (D2), U9.4 (D1)
/D3: J2.B11 (D3), U2.15 (D3), U3.8 (DI3), U7.15 (D3), U9.17 (D6)
/D4: J2.B12 (D4), U2.16 (D4), U3.9 (DI4), U7.16 (D4), U9.14 (D5)
/D5: J2.B10 (D5), U2.17 (D5), U3.10 (DI5), U7.17 (D5), U9.7 (D2)
/D6: J2.B9 (D6), U2.18 (D6), U3.11 (DI6), U6.12 (D2), U7.18 (D6), U9.8 (D3)
/D7: J2.B3 (D7), U2.19 (D7), U3.12 (DI7), U5.6, U6.13 (D3), U7.19 (D7), U9.13 (D4)
/DS0: J1.10, U5.11
/DS1: J1.12, U5.8
/IOREQ: J2.B17 (IOREQ), U8.5 (I5)
/M1: J2.B24 (M1), U10.4
/MREQ: J2.B16 (MREQ), U8.4 (I4)
/RD: J2.B18 (RD), U2.22 (~OE), U7.20 (~CE), U8.6 (I6)
/RESET: C3.2, J2.A20 (~RESET), U3.13 (~MR), U6.1 (~Mr)
/WR: J2.B19 (WR), U3.2 (R/~W), U7.27 (~WR), U8.7 (I7)
/XXX: J1.32, U5.3
DSK_CS: U6.9 (Cp), U8.19 (IO19)
FDC_CS: U3.1 (~CS), U8.22 (IO22)
GND: C3.1, C4.1, C5.1, C6.2, C7.2, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, J1.1, J1.3, J1.5, J1.7, J1.9, J1.11, J1.13, J1.15, J1.17, J1.19, J1.21, J1.23, J1.25, J1.27, J1.29, J1.31, J1.33, J2.A6 (GND), J2.A7 (GND), J2.A14 (GND), J3.2, J3.4, J3.6, J3.8, J3.10, J3.12, J3.14, J3.16, J3.18, J3.20, J3.22, J3.24, J5.0 (PAD), J5.14, J5.15, J5.16, J5.17, J5.18, J5.19, J5.20, J5.21, J5.22, J5.23, J5.24, J5.25, MK2.1, SW2.3, SW2.4, U1.7 (GND), U3.14 (GND), U3.26 (~DDEN), U4.14 (VCC), U5.7 (GND), U6.8 (GND), U7.1 (A14), U7.14 (GND), U7.26 (A13), U8.12 (GND), U9.1 (OE), U9.10 (GND), U10.7 (GND), U12.2 (GND)
NMI: J2.B14 (~NMI), SW1.1 (A)
unnamed: C1.1, R6.2, U4.6
unnamed: C1.2, R5.1, U4.1, U4.2
unnamed: C2.1, Y1.1
unnamed: C2.2, R5.2, U3.18 (CLK), U4.3
unnamed: C4.2, R8.1, U8.23 (I23)
unnamed: D1.2 (A), D3.2 (A), J4.3
unnamed: D2.1 (K), J4.2, SW1.2 (B), U8.21 (IO21)
unnamed: D2.2 (A), R7.1
unnamed: D4.2 (A), J4.1
unnamed: J1.8, R1.1, U3.24 (~IP)
unnamed: J1.16, U1.4
unnamed: J1.18, U1.10
unnamed: J1.20, U1.6
unnamed: J1.22, U1.2
unnamed: J1.24, U1.12
unnamed: J1.26, R2.1, U3.23 (~TR00)
unnamed: J1.28, R3.1, U3.25 (~WPRT)
unnamed: J1.30, R4.1, U3.19 (~RD)
unnamed: J3.1, J5.1, U1.8
unnamed: J3.3, U9.19 (O7)
unnamed: J3.5, U9.2 (O0)
unnamed: J3.7, U9.5 (O1)
unnamed: J3.9, U9.16 (O6)
unnamed: J3.11, U9.15 (O5)
unnamed: J3.13, U9.6 (O2)
unnamed: J3.15, U9.9 (O3)
unnamed: J3.17, U9.12 (O4)
unnamed: J3.21, J5.11, R9.1, U5.5
unnamed: R6.1, U4.4, U4.5, Y1.2
unnamed: R8.2, U10.6
unnamed: U1.1, U3.22 (WD)
unnamed: U1.3, U3.20 (MOTOR)
unnamed: U1.5, U3.16 (STEP)
unnamed: U1.9, U6.10 (Q2)
unnamed: U1.11, U3.17 (DIRC)
unnamed: U1.13, U3.21 (WG)
unnamed: U4.8, U5.4
unnamed: U5.2, U6.14 (~Q3)
unnamed: U5.9, U6.6 (~Q1)
unnamed: U5.12, U6.3 (~Q0)
unnamed: U4.11, U10.5
unnamed: U4.12, U10.8
unnamed: U4.13, U10.12
PRN_CS: U8.18 (IO18), U9.11 (Cp)
PRN_STR: U4.9, U4.10, U8.20 (I020)
RAM_CS: U7.22 (~OE), U8.16 (IO16)
ROM_A13: R11.1, SW2.1, U2.26 (A13)
ROM_A14: R10.1, SW2.2, U2.1 (A14)
ROM_CS: U2.20 (~CE), U8.15 (IO15)
ZX_ROMOE1: D1.1 (K), J2.B4 (N/C-ROM1_OE)
ZX_ROMOE2: D3.1 (K), J2.A15 (VIDEO-ROM2_OE)
ZX_ROMOE48: D4.1 (K), J2.A25 (ROMCS-N/C)

Board: 2 copper layers, 99.0 x 87.6 mm, 52 parts (0 on the bottom side), 91 nets.

## Commit log

2018-06-12 Inicial
2018-06-12 readme
2018-06-28 ahora con joystick
2018-06-30 add cable jumpers
2018-07-15 fix power to chips
2018-07-31 add schematic and BOM
2018-08-04 Rev 03, first prototipe, only for the record
2018-08-04 correcciones esteticas
2018-08-12 aestetical changes
2018-08-19 More files
2019-02-25 Update Schematic
2021-04-03 update license
2023-04-26 añadido ibom

Notices in the files:
Rev_02/plusd.kicad_pcb:
(C) 2018
